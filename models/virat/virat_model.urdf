Commit message: fixed instability issue while spawning

File: models/virat/virat_model.urdf (robot description, URDF)
Before this commit: robot clueless_virat, 5 links, 4 joints
Links:
- link base_link: mass 0.5 -> 2
